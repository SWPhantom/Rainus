// One SD v2+ card in the nanoCH32V203 v1.1 socket, using SPI1 in 8-bit mode.
// Supports byte-addressed SDSC and sector-addressed SDHC/SDXC cards. FatFs
// supplies sector requests; this file implements the SD wire protocol only.
// Protocol fields follow the SD Physical Layer specification's SPI chapter;
// polling limits below are this driver's choices, not protocol field values.
#include "ch32fun.h"
#include "fatfs/diskio.h"

#define SD_CS_PIN   PA3 // Chip select: LOW selects the card, HIGH releases it.
#define SD_SCK_PIN  PA5 // Clock generated by the MCU.
#define SD_MISO_PIN PA6 // Card -> MCU data.
#define SD_MOSI_PIN PA7 // MCU -> card data.

enum {
    SD_DRIVE_NUMBER = 0, // FatFs drive number for our only socket.
    SD_SECTOR_BYTES = 512,
    SD_EXTENDED_RESPONSE_BYTES = 4, // Bytes following R1 for CMD8/CMD58.
    SD_DATA_CRC_BYTES = 2,
    SD_ERASE_BLOCK_HINT_SECTORS = 1 // Placeholder; erase geometry isn't queried.
};

// SD command indexes. ACMD41 must be preceded by CMD55 (APP_CMD).
enum {
    SD_CMD_GO_IDLE = 0,
    SD_CMD_SEND_IF_COND = 8,
    SD_CMD_SET_BLOCKLEN = 16,
    SD_CMD_READ_SINGLE_BLOCK = 17,
    SD_CMD_WRITE_SINGLE_BLOCK = 24,
    SD_ACMD_SEND_OP_COND = 41,
    SD_CMD_APP_CMD = 55,
    SD_CMD_READ_OCR = 58
};

enum {
    SD_SPI_FILL_BYTE = 0xff, // Clock the bus with outgoing data held HIGH.
    SD_NO_RESPONSE = 0xff,   // Not a valid R1 byte; helper's failure sentinel.
    SD_COMMAND_PREFIX = 0x40, // Command byte starts with bits 01, then index.
    SD_R1_START_BIT_MASK = 0x80, // A valid R1 response has its top bit clear.
    SD_R1_READY = 0x00,
    SD_R1_IDLE = 0x01,
    SD_DATA_START_TOKEN = 0xfe,
    SD_WRITE_RESPONSE_MASK = 0x1f,
    SD_WRITE_ACCEPTED = 0x05,
    SD_CMD0_CRC_BYTE = 0x95, // CRC7 + end bit for CMD0 with argument zero.
    SD_CMD8_CRC_BYTE = 0x87, // CRC7 + end bit for SD_IF_COND_ARGUMENT below.
    SD_IF_COND_VOLTAGE_CODE = 1, // CMD8's code for the 2.7-3.6 V range.
    SD_IF_COND_CHECK_PATTERN = 0xaa,
    SD_IF_COND_ARGUMENT = (SD_IF_COND_VOLTAGE_CODE << 8) | SD_IF_COND_CHECK_PATTERN,
    SD_IF_COND_VOLTAGE_BYTE = 2, // Field positions in CMD8's four extra bytes.
    SD_IF_COND_PATTERN_BYTE = 3,
    SD_INIT_HIGH_CAPACITY_FLAG = 0x40000000, // ACMD41: host supports SDHC/SDXC.
    SD_OCR_SECTOR_ADDRESSING_MASK = 0x40 // Bit 30 of OCR, in its first byte.
};

// Preserve the polling budgets used by the tested firmware. Delays are in
// milliseconds; transfer and interrupt time is additional, so these are not
// exact elapsed-time deadlines. Ready checks have an initial poll + retries.
enum {
    SD_POLL_DELAY_MS = 1,
    SD_SELECT_READY_RETRIES = 500,
    SD_WRITE_READY_RETRIES = 1000,
    SD_COMMAND_RESPONSE_POLLS = 10,
    SD_READ_TOKEN_POLLS = 250,
    SD_POWER_SETTLE_MS = 100,
    SD_STARTUP_CLOCK_BYTES = 10, // 80 clocks with CS/MOSI HIGH (at least 74 needed).
    SD_RESET_ATTEMPTS = 100,
    SD_RESET_RETRY_DELAY_MS = 10,
    SD_INIT_ATTEMPTS = 1000
};

static DSTATUS disk_state = STA_NOINIT;
static int card_uses_sector_addresses;

// Exchange one byte: SPI transmits and receives simultaneously. TXE says the
// transmit buffer has room; writing DATAR starts a transfer. RXNE says the
// received byte is available. These are hardware polls, not software locks.
// These two waits remain unbounded; adding fault bounds is a separate change.
static uint8_t spi_exchange_byte(uint8_t outgoing)
{
    while (!(SPI1->STATR & SPI_STATR_TXE)) {}
    SPI1->DATAR = outgoing;
    while (!(SPI1->STATR & SPI_STATR_RXNE)) {}
    return SPI1->DATAR;
}

static void sd_deselect(void)
{
    funDigitalWrite(SD_CS_PIN, FUN_HIGH);
    // Eight trailing clocks let the card finish the exchange/release MISO.
    spi_exchange_byte(SD_SPI_FILL_BYTE);
}

// Called with CS LOW. A busy card holds incoming data LOW; all HIGH bits
// (0xFF) mean ready. Sending fill bytes supplies the clocks to sample that.
// Return 1 when ready, 0 after the initial poll and allowed retries all fail.
static int sd_wait_ready(unsigned retries_remaining)
{
    for (;;) {
        if (spi_exchange_byte(SD_SPI_FILL_BYTE) == SD_SPI_FILL_BYTE) return 1;
        Delay_Ms(SD_POLL_DELAY_MS);
        if (retries_remaining == 0) return 0;
        --retries_remaining;
    }
}

// There is only one card: select its fixed CS pin, then wait for readiness.
// Return 1 with CS still LOW, or 0 with the card deselected on failure.
static int sd_select_and_wait_ready(void)
{
    funDigitalWrite(SD_CS_PIN, FUN_LOW);
    spi_exchange_byte(SD_SPI_FILL_BYTE);
    if (sd_wait_ready(SD_SELECT_READY_RETRIES)) return 1;
    sd_deselect();
    return 0;
}

// Send a six-byte SD command packet and read its first response byte (R1).
// Return the card's R1 status, or SD_NO_RESPONSE if selection/response fails.
// After sending a packet, CS stays LOW so the caller can transfer extra
// response bytes or data. The caller must deselect when the operation ends.
static uint8_t sd_send_command(uint8_t command_index, uint32_t argument)
{
    sd_deselect();
    if (command_index == SD_CMD_GO_IDLE) {
        // CMD0 switches a newly powered card into SPI mode. Waiting for SPI
        // readiness BEFORE that command caused our SanDisk cold-start failure.
        funDigitalWrite(SD_CS_PIN, FUN_LOW);
        spi_exchange_byte(SD_SPI_FILL_BYTE);
    } else if (!sd_select_and_wait_ready()) {
        return SD_NO_RESPONSE;
    }

    spi_exchange_byte(SD_COMMAND_PREFIX | command_index);
    // Serialize the 32-bit argument one byte at a time, most significant first.
    spi_exchange_byte(argument >> 24);
    spi_exchange_byte(argument >> 16);
    spi_exchange_byte(argument >> 8);
    spi_exchange_byte(argument);

    // CRC checking is off for ordinary SPI commands. CMD0 and CMD8 require
    // the valid CRC/end-bit bytes for their fixed arguments used here.
    uint8_t crc = SD_SPI_FILL_BYTE;
    if (command_index == SD_CMD_GO_IDLE) crc = SD_CMD0_CRC_BYTE;
    else if (command_index == SD_CMD_SEND_IF_COND) crc = SD_CMD8_CRC_BYTE;
    spi_exchange_byte(crc);

    // Keep supplying clocks until R1 starts. READY/IDLE are expected statuses;
    // other R1 bits describe card errors and are checked by each caller.
    for (unsigned poll = 0; poll < SD_COMMAND_RESPONSE_POLLS; ++poll) {
        uint8_t response = spi_exchange_byte(SD_SPI_FILL_BYTE);
        if (!(response & SD_R1_START_BIT_MASK)) return response;
    }
    return SD_NO_RESPONSE;
}

// FatFs always supplies 512-byte sector numbers. SDSC commands take a byte
// address instead; SDHC/SDXC commands take the sector number directly.
static uint32_t sd_sector_address(LBA_t sector)
{
    return card_uses_sector_addresses ? sector : sector * SD_SECTOR_BYTES;
}

// FatFs interface: return status flags, with zero meaning initialized/ready.
// Only SD v2+ initialization is supported; legacy SD v1/MMC is not attempted.
DSTATUS disk_initialize(BYTE drive)
{
    if (drive != SD_DRIVE_NUMBER) return STA_NOINIT;
    disk_state = STA_NOINIT;
    card_uses_sector_addresses = 0;
    RCC->APB2PCENR |= RCC_APB2Periph_SPI1;
    funDigitalWrite(SD_CS_PIN, FUN_HIGH);
    funPinMode(SD_CS_PIN, GPIO_CFGLR_OUT_10Mhz_PP);
    funPinMode(SD_SCK_PIN, GPIO_CFGLR_OUT_10Mhz_AF_PP);
    funPinMode(SD_MISO_PIN, GPIO_CFGLR_IN_FLOAT);
    funPinMode(SD_MOSI_PIN, GPIO_CFGLR_OUT_10Mhz_AF_PP);
    // Master, 8-bit mode 0 (CPOL/CPHA clear). Software controls external CS;
    // SSM/SSI keep the SPI peripheral's own NSS input logically inactive.
    const uint16_t spi_config = SPI_CTLR1_MSTR | SPI_CTLR1_SSM | SPI_CTLR1_SSI | SPI_CTLR1_SPE;
    // Keep initialization within the SD card's 100-400 kHz range.
#if RAINUS_DEBUG_USB
    const uint16_t init_speed = SPI_CTLR1_BR; // 48 MHz / 256 = 187.5 kHz.
#else
    const uint16_t init_speed = SPI_CTLR1_BR_2; // 8 MHz / 32 = 250 kHz.
#endif
    SPI1->CTLR1 = spi_config | init_speed;
    Delay_Ms(SD_POWER_SETTLE_MS);
    for (unsigned i = 0; i < SD_STARTUP_CLOCK_BYTES; ++i)
        spi_exchange_byte(SD_SPI_FILL_BYTE);

    // Stage 1: reset into SPI mode. The bounded retries fixed the remaining
    // SanDisk cold-start issue; a successful reset returns the IDLE status.
    int reset_ok = 0;
    for (unsigned attempt = 0; attempt < SD_RESET_ATTEMPTS; ++attempt) {
        if (sd_send_command(SD_CMD_GO_IDLE, 0) == SD_R1_IDLE) {
            reset_ok = 1;
            break;
        }
        Delay_Ms(SD_RESET_RETRY_DELAY_MS);
    }
    if (!reset_ok) goto done;

    // Stage 2: CMD8 returns R1 plus four bytes echoing voltage/check pattern.
    if (sd_send_command(SD_CMD_SEND_IF_COND, SD_IF_COND_ARGUMENT) != SD_R1_IDLE) goto done;
    uint8_t interface_response[SD_EXTENDED_RESPONSE_BYTES];
    for (unsigned i = 0; i < SD_EXTENDED_RESPONSE_BYTES; ++i)
        interface_response[i] = spi_exchange_byte(SD_SPI_FILL_BYTE);
    if (interface_response[SD_IF_COND_VOLTAGE_BYTE] != SD_IF_COND_VOLTAGE_CODE ||
        interface_response[SD_IF_COND_PATTERN_BYTE] != SD_IF_COND_CHECK_PATTERN) goto done;

    // Stage 3: CMD55 prefixes ACMD41. Repeat while the card remains IDLE;
    // R1=READY means initialization has finished. Values above IDLE are errors.
    int initialized = 0;
    for (unsigned attempt = 0; attempt < SD_INIT_ATTEMPTS; ++attempt) {
        if (sd_send_command(SD_CMD_APP_CMD, 0) > SD_R1_IDLE) break;
        if (sd_send_command(SD_ACMD_SEND_OP_COND, SD_INIT_HIGH_CAPACITY_FLAG) == SD_R1_READY) {
            initialized = 1;
            break;
        }
        Delay_Ms(SD_POLL_DELAY_MS);
    }
    if (!initialized) goto done;

    // Stage 4: OCR reports the address units. We need only its first byte,
    // but must clock out the remaining bytes to finish the response.
    if (sd_send_command(SD_CMD_READ_OCR, 0) != SD_R1_READY) goto done;
    uint8_t ocr_first_byte = spi_exchange_byte(SD_SPI_FILL_BYTE);
    for (unsigned i = 0; i < SD_EXTENDED_RESPONSE_BYTES - 1; ++i)
        spi_exchange_byte(SD_SPI_FILL_BYTE);
    card_uses_sector_addresses = !!(ocr_first_byte & SD_OCR_SECTOR_ADDRESSING_MASK);
    if (!card_uses_sector_addresses) {
        if (sd_send_command(SD_CMD_SET_BLOCKLEN, SD_SECTOR_BYTES) != SD_R1_READY) goto done;
    }
    disk_state = 0; // No FatFs status flags: initialization succeeded.
    // Preserve the tested transfer speed: 250 kHz field / 1.5 MHz USB debug.
    SPI1->CTLR1 = spi_config | SPI_CTLR1_BR_2;
done:
    sd_deselect();
    return disk_state;
}

DSTATUS disk_status(BYTE drive)
{
    return drive == SD_DRIVE_NUMBER ? disk_state : STA_NOINIT;
}

// FatFs sector I/O: RES_OK on success, RES_NOTRDY for the existing invalid /
// uninitialized request cases, RES_ERROR for command/token/card failures.
// These results propagate through FatFs to Rainus's terminal error handler.
DRESULT disk_read(BYTE drive, BYTE *buffer, LBA_t sector, UINT count)
{
    if (drive != SD_DRIVE_NUMBER || (disk_state & STA_NOINIT) || count == 0) return RES_NOTRDY;
    while (count > 0) {
        if (sd_send_command(SD_CMD_READ_SINGLE_BLOCK, sd_sector_address(sector)) != SD_R1_READY)
            goto fail;
        uint8_t token = SD_SPI_FILL_BYTE;
        for (unsigned poll = 0; poll < SD_READ_TOKEN_POLLS; ++poll) {
            token = spi_exchange_byte(SD_SPI_FILL_BYTE);
            if (token != SD_SPI_FILL_BYTE) break;
            Delay_Ms(SD_POLL_DELAY_MS);
        }
        if (token != SD_DATA_START_TOKEN) goto fail;
        for (unsigned i = 0; i < SD_SECTOR_BYTES; ++i)
            *buffer++ = spi_exchange_byte(SD_SPI_FILL_BYTE);
        // Consume the trailing CRC even though this driver does not verify it.
        for (unsigned i = 0; i < SD_DATA_CRC_BYTES; ++i)
            spi_exchange_byte(SD_SPI_FILL_BYTE);
        ++sector;
        --count;
    }
    sd_deselect();
    return RES_OK;
fail:
    sd_deselect();
    return RES_ERROR;
}

DRESULT disk_write(BYTE drive, const BYTE *buffer, LBA_t sector, UINT count)
{
    if (drive != SD_DRIVE_NUMBER || (disk_state & STA_NOINIT) || count == 0) return RES_NOTRDY;
    while (count > 0) {
        if (sd_send_command(SD_CMD_WRITE_SINGLE_BLOCK, sd_sector_address(sector)) != SD_R1_READY)
            goto fail;
        spi_exchange_byte(SD_DATA_START_TOKEN);
        for (unsigned i = 0; i < SD_SECTOR_BYTES; ++i) spi_exchange_byte(*buffer++);
        // Dummy CRC is allowed with data CRC checking disabled in SPI mode.
        for (unsigned i = 0; i < SD_DATA_CRC_BYTES; ++i)
            spi_exchange_byte(SD_SPI_FILL_BYTE);
        uint8_t response = spi_exchange_byte(SD_SPI_FILL_BYTE);
        if ((response & SD_WRITE_RESPONSE_MASK) != SD_WRITE_ACCEPTED) goto fail;
        // Accepted means the packet arrived; wait for internal programming too.
        if (!sd_wait_ready(SD_WRITE_READY_RETRIES)) goto fail;
        ++sector;
        --count;
    }
    sd_deselect();
    return RES_OK;
fail:
    sd_deselect();
    return RES_ERROR;
}

// FatFs control requests. CTRL_SYNC waits for the card to finish programming.
DRESULT disk_ioctl(BYTE drive, BYTE cmd, void *buffer)
{
    if (drive != SD_DRIVE_NUMBER || (disk_state & STA_NOINIT)) return RES_NOTRDY;
    switch (cmd) {
    case CTRL_SYNC:
        if (!sd_select_and_wait_ready()) return RES_ERROR;
        sd_deselect();
        return RES_OK;
    case GET_SECTOR_SIZE:
        *(WORD *)buffer = SD_SECTOR_BYTES;
        return RES_OK;
    case GET_BLOCK_SIZE:
        // Conservative formatting hint, not the card's measured erase size.
        *(DWORD *)buffer = SD_ERASE_BLOCK_HINT_SECTORS;
        return RES_OK;
    default:
        return RES_PARERR;
    }
}
